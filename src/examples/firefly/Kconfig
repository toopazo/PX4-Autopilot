## src/examples/firefly/Kconfig
```kconfig
menuconfig EXAMPLES_FIREFLY
	bool "firefly"
	default n
	---help---
		Enable support for firefly
```
